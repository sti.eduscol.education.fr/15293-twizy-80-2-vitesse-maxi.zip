simulink model "Test_4"  (R2021b)
settings: Solver=FixedStepAuto  StartTime=0.0  StopTime=1200
undefined symbols (not defined in the file): Ion, Lithium, Pe
libraries: fl_lib x31, nesl_utility x24, sdl_lib x11, simulink x5, simulink_extras x2, spsBatteryLib x1, spsCurrentVoltageSimscapeInterfaceLib x1, slpidlib x1, spspowerguiLib x1
(part 2 of 2)

== stateflow chart Test_4/Cycle NEDC ==
  state Cycles_NDEC
    during:
    Consigne_acc=10*Consigne/8;
    state E0
      entry:
      Nb_cycle = Nb_cycle + 1;
      Consigne=0;
    state E01
      during:
      t=temporalCount(sec);
      Consigne=25*t/13;
    state E016
      Consigne=70;
    state E02
      Consigne=15;
    state E017
      during:
      t=temporalCount(sec);
      Consigne=70-25*t/13;
    state E03
      during:
      t=temporalCount(sec);
      Consigne=15-25*t/13;
    state E05
      during:
      t=temporalCount(sec);
      Consigne=25*t/13;
    state E018
      Consigne=50;
    state E04
      Consigne=0;
    state E06
      Consigne=32;
    state E019
      during:
      t=temporalCount(sec);
      Consigne=50+25*t/13;
    state E07
      during:
      t=temporalCount(sec);
      Consigne=32-25*t/13;
    state E020
      Consigne=70;
    state E026
      Consigne=0;
    state E08
      Consigne=0;
    state E011
      during:
      t=temporalCount(sec);
      Consigne=25*t/13;
    state E021
      during:
      t=temporalCount(sec);
      Consigne=70+25*t/13;
    state E025
      during:
      t=temporalCount(sec);
      Consigne=130-25*t/13;
    state E012
      Consigne=50;
    state E022
      Consigne=100;
    state E09
      during:
      t=temporalCount(sec);
      Consigne=50-25*t/13;
    state E023
      during:
      t=temporalCount(sec);
      Consigne=100+25*t/13;
    state E024
      Consigne=130;
    state E010
      Consigne=35;
    state E015
      during:
      t=temporalCount(sec);
      Consigne=35-25*t/13;
    (default) -> E0 : {Nb_cycle=0;}
    E0 -> E01 : after(8,sec)
    E015 -> E0 : [Consigne<=0]
    E01 -> E016 : [Consigne>=70&&Nb_cycle>4]
    E01 -> E02 : [Consigne>=15&&Nb_cycle<=4]
    E016 -> E017 : after(60,sec)
    E02 -> E03 : after(8,sec)
    E017 -> E018 : [Consigne<=50]
    E03 -> E04 : [Consigne<=0]
    E04 -> E05 : after(20,sec)
    E018 -> E019 : after(75,sec)
    E05 -> E06 : [Consigne>=32]
    E06 -> E07 : after(20,sec)
    E019 -> E020 : [Consigne>=70]
    E07 -> E08 : [Consigne<=0]
    E020 -> E021 : after(54,sec)
    E08 -> E011 : after(20,sec)
    E025 -> E026 : [Consigne<=0]
    E011 -> E012 : [Consigne>=50]
    E021 -> E022 : [Consigne>=100]
    E012 -> E09 : after(8,sec)
    E024 -> E025 : after(10,sec)
    E022 -> E023 : after(40,sec)
    E023 -> E024 : [Consigne>=130]
    E09 -> E010 : [Consigne<=35]
    E010 -> E015 : after(8,sec)
  (default) -> Cycles_NDEC
  data: Consigne output; t local; Nb_cycle local; Consigne_acc output

== matlab function Test_4/Modele ensemble variateur Sevcon et moteur asynchrone Letrika
en fonctionnement moyen/Capteur meca rotation/MATLAB Function2 ==
function Quadrant_meca = fcn(Cm,Nm)
if Nm > 1
    if Cm > 0
        Quadrant_meca = 1;
    elseif Cm < 0
        Quadrant_meca = 4;
    else
        Quadrant_meca = 0;
    end
elseif Nm < -1
    if Cm > 0
        Quadrant_meca = 2;
    elseif Cm < 0
        Quadrant_meca = 3;
    else
        Quadrant_meca = 0;
    end
else
    Quadrant_meca = 0;
end
end

== matlab function Test_4/Batteries lithium/Mesures batteries/MATLAB Function2 ==
function Quadrant_elec = fcn(I_bat,U_bat)
if U_bat > 0.8
    if I_bat > 0.3
        Quadrant_elec = 1;
    elseif I_bat < -0.5
        Quadrant_elec = 4;
    else
        Quadrant_elec = 0;
    end
elseif U_bat < -0.8
    if I_bat > 0.5
        Quadrant_elec = 2;
    elseif I_bat < -0.5
        Quadrant_elec = 3;
    else
        Quadrant_elec = 0;
    end
else
    Quadrant_elec = 0;
end
end

== matlab function Test_4/Modele ensemble variateur Sevcon et moteur asynchrone Letrika
en fonctionnement moyen/MATLAB Function ==
function [T_out,P_meca]= fcn(Consigne_frequence, T_in,Nn,Tn,Un,U_bat,Nmes)
if U_bat <= Un
    k_corr = (U_bat/Un).^2;
else
    k_corr = 1;
end
P_max = Tn*(2*pi*Nn/60)*k_corr;

if Consigne_frequence~=0
    if abs(Nmes)<=Nn
        if abs(T_in)>=Tn*k_corr
            T_out=Tn*sign(T_in)*k_corr;
        else
            T_out=T_in*k_corr;
        end
    else
        if abs(T_in)>=P_max/(2*pi*Nmes/60)
            T_out=sign(T_in)*P_max/(2*pi*Nmes/60);
        else
            T_out=T_in;
        end
    end
else
    T_out=0;
end

P_meca = T_out*2*pi*Nmes/60;

end
